# Keil uVision project AT32F423VCT7_TEST.uvprojx, settings and files
target AT32F423VCT7_TEST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F423VCT7 ArteryTek
  pack: ArteryTek.AT32F423_DFP.2.0.9
  cpu: IRAM(0x20000000,0x3000000) IROM(0x08000000,0x10000000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F423VCT7_TEST +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F423VCT7,USE_STDPERIPH_DRIVER,AT_START_F423_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\middlewares\freertos\source\include;..\..\middlewares\freertos\source\portable\rvds\ARM_CM4F;..\..\TASK;..\..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../src/: at32f423_int.c at32f423_wk_config.c main.c wk_system.c
  group firmware
    ../../libraries/drivers/src/: at32f423_crm.c at32f423_tmr.c at32f423_gpio.c at32f423_usart.c at32f423_pwc.c at32f423_debug.c at32f423_flash.c at32f423_exint.c at32f423_misc.c at32f423_scfg.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f423.c
    ./: startup_at32f423.s
  group OS
    ../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../middlewares/freertos/source/portable/rvds/ARM_CM4F/: port.c
    ../../middlewares/freertos/source/portable/memmang/: heap_4.c
  group TASK
    ../../TASK/: FreeRTOS_TASK.c
  group APP
    ../../APP/: led.c key.c
